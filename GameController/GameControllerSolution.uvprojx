# Keil uVision project GameControllerSolution.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GameControllerSolution
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group src
    ./: main.c
  group inc
    ./: main.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, Board Support:Drivers:Touch Screen 1.1.0, Board Support:Touchscreen 1.1.0, CMSIS Driver:USART 1.20.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:ADC 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:EXTI 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:LPTIM 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:TIM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.2.5
